# Keil uVision project E6202Prj.uvproj, settings and files
target E6202 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ..\..\bin\E9624 +hex
  AfterMake: .\bincrc.bat  E9624 C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o ../bin/E9624.bin ../bin/E9624.axf
  c flags: Optim=1 OneElfS=1
  c include: ..\App\inc;..\Driver;..\CMSIS;..\StdPeriphDrv\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/src/: AppPrintf.c main.c Shell.c SysTick.c template.c CipherFunc.c Public.c
    ../App/inc/: template.h AppPrintf.h main.h Shell.h SysTick.h CipherFunc.h Public.h
  group Driver
    ../Driver/: CanDrv.c CanDrv.h GPIO.c GPIO.h Uart.c Uart.h bsp.c bsp.h
  group CMSIS
    ../CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c stm32f10x_conf.h
  group StdPeriphDrv
    ../StdPeriphDrv/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../StdPeriphDrv/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK-ARM
    ./: startup_stm32f10x_cl.s
  group Doc
    ../Doc/: 版本说明.txt
